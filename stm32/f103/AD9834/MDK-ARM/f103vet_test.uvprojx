# Keil uVision project f103vet_test.uvprojx, settings and files
target f103vet_test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: f103vet_test +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;.\use_ware\use_self\GPIO;.\use_ware\use_self\OLED;.\use_ware\sys\inc;.\use_ware\use_self\USART3;.\use_ware\use_self\TIMER;.\use_ware\esp8266\inc;.\use_ware\AD9834;.\use_ware\use_self\ot_AD9834
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c main.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pwr.c stm32f1xx_hal.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group sys
    ./use_ware/sys/: sys.c delay.c
  group use_ware
    ./use_ware/use_self/GPIO/: GPIO.c
    ./use_ware/use_self/OLED/: OLED.c
    ./use_ware/use_self/USART3/: usart3.c
    ./use_ware/use_self/TIMER/: timer.c
    ./use_ware/use_self/ot_AD9834/: ot_AD9834.c
  group esp8266
    ./use_ware/esp8266/: commom.c
  group AD9834
    ./use_ware/AD9834/: AD9834.c
software components: CMSIS:CORE 4.1.0
